# Keil uVision project LED Control.uvprojx, settings and files
target TM4C123GH6PM (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED Control
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Source\Common;..\Source\MCAL;..\Source\MCAL\Include;..\Source\App;..\Source\Config
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../Source/App/: Main.c
  group Libraries
    ../Source/Common/: Bit_Math.h Compiler.h Mcu_Hw.h Platform_Types.h Std_Types.h
  group MCAL
    ../Source/MCAL/: Cpu_Driver.c Mcu.c Nvic.c Timer.c
    ../Source/MCAL/Include/: Cpu_Driver.h Mcu.h Nvic.h Timer.h
    ../Source/Config/: Mcu_Cfg.h Mcu_Lcfg.c Nvic_Cfg.h Nvic_Lcfg.c Timer_Cfg.h Timer_Lcfg.c
target Application (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: LED Control
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
